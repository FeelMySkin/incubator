# Keil uVision project Incubator.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Incubator
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c include: .\;..\STM32_Libs\STM32CubeF0\Drivers\CMSIS\Core\Include;..\STM32_Libs\STM32CubeF0\Drivers\STM32F0xx_HAL_Driver\Inc;..\STM32_Libs\STM32CubeF0\Drivers\STM32F0xx_HAL_Driver\Src;..\STM32_Libs\STM32CubeF0\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\STM32_Libs\STM32CubeF0\Drivers\CMSIS\Device\ST\STM32F0xx\Source\Templates
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: main.c main.h
  group LL
    ../STM32_Libs/STM32CubeF0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c
  group Startup
    ./: startup_stm32f030x6.s
    ../STM32_Libs/STM32CubeF0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
