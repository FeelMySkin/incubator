# Keil uVision project Incubator.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Incubator
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  c misc: --cpp11
  c include: .\RTE\_Target_1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: Source.cpp periph_use.c heater_controller.cpp i2c_controller.cpp lcd_controller.cpp adc_controller.cpp pid_controller.cpp hts221.cpp
  group New Group
    ./: Source.h defines.h periph_use.h heater_controller.h i2c_controller.h lcd_controller.h adc_controller.h pid_controller.h hts221.h
    ./RTE/_Target_1/: RTE_Components.h
software components: CMSIS:CORE 5.5.0, Device:STM32Cube LL:ADC 1.7.0, Device:STM32Cube LL:COMMON 1.7.0, Device:STM32Cube LL:DMA 1.7.0, Device:STM32Cube LL:GPIO 1.7.0, Device:STM32Cube LL:I2C 1.7.0, Device:STM32Cube LL:PWR 1.7.0, Device:STM32Cube LL:RCC 1.7.0, Device:STM32Cube LL:TIM 1.7.0, Device:STM32Cube LL:UTILS 1.7.0, Device:Startup 1.0.0
